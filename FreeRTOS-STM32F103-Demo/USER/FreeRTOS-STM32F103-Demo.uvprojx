# Keil uVision project FreeRTOS-STM32F103-Demo.uvprojx, settings and files
target FreeRTOS-STM32F103-DEMO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS-STM32F103-Demo +hex
  c flags: Optim=1
  c define: STM32F10X_ HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\COER;..\STM32F10x_FWLib\inc;..\HAL;..\SYSTEM;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HAL\ENCODER;..\HAL\TIMER;..\FreeRTOS;..\FreeRTOS\include;..\HAL\PWM
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group CORE
    ../COER/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HAL
    ../HAL/TIMER/: timer.c
    ../HAL/ENCODER/: encoder.c
    ../HAL/PWM/: pwm.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c heap_2.c list.c port.c queue.c tasks.c timers.c
  group FreeRTOS\include
    ../FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h portmacro.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
